IMAGE_INSTALL:append = " u-boot"